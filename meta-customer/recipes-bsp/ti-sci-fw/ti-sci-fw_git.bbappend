TI_SYSFW_VERSION = "11.01.02"
TI_LINUX_FW_SRCREV = "33bec0e2ea9a25362c0c8243b2f1ed392dbc5b02"
