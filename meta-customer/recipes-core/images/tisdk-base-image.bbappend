# fw_setenv & fw_printenv
IMAGE_INSTALL:append = " u-boot-fw-utils"
